# Keil uVision project CH561.uvproj, settings and files
target QITAS (5060750::V5.06 update 6 (build 750)::ARMCC)
  device: STR912FAW44 STMicroelectronics
  cpu: IRAM(0x04000000-0x04017FFF) IROM(0x0-0x7FFFF) IROM2(0x400000-0x407FFF) CLOCK(25000000) CPUTYPE(ARM966E-S)
  output: CH561 +hex
  c flags: Optim=3 v6Lang=1 v6LangP=1
  c include: .\SRC;.\NET\PUB
  asm define: STARTUP_OF_CH561
  library: MicroLIB
  memory RVCT4: ROM 0x0 size 0x80000
  memory RVCT5: ROM 0x400000 size 0x8000
  memory RVCT9: RAM 0x4000000 size 0x18000
  scatter file: .\SRC\CH561D32.SCF
  group User
    ./NET/UDP_SERVER/: UDP_SERVER.C
  group Sys
    ./SRC/: SYSFREQ.C STARTUP.S
  group Lib
    ./SRC/: ISPXT56X.O
    ./NET/PUB/: CH561NET.lib
